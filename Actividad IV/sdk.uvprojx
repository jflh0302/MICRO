# Keil uVision project sdk.uvprojx, settings and files
target sdk (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdk +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: includes
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sources
    ./: main.c ext_in.c images.c delay.c fonts.c gpio.c i2c.c leds.c ssd1306.c
  group includes
    ./: delay.h ext_in.h fonts.h gpio.h i2c.h images.h leds.h ssd1306.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
